SRCBRANCH ?= "master"
SRCREV = "1ed3945e30d717f4d31403ab72858d89cec32fc0"

include open-amp.inc
