SRCBRANCH ?= "master"
SRCREV = "b51cffb822b7f5330c4e752311de17b841d31fd2"

include libmetal.inc

