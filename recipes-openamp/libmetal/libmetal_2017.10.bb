SRCBRANCH ?= "master"
SRCREV = "18048c4144f276cda793c125399057a6b5773edb"

include libmetal.inc

